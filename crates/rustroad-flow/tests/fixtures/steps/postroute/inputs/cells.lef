VERSION 5.8 ;
MACRO BUFX1
  CLASS CORE ;
  SIZE 1.44 BY 3.33 ;
  PIN A
    DIRECTION INPUT ;
  END A
END BUFX1
MACRO BUFX2
  SIZE 1.44 BY 3.33 ;
END BUFX2
MACRO BUFX4
  FOREIGN BUFX4 ;
  SIZE   1.440   BY   3.330 ;
END BUFX4
MACRO BUFX8
  SIZE 2.88 BY 3.33 ;
END BUFX8
MACRO INVX1
  SIZE 0.9605 BY 3.33 ;
END INVX1
MACRO INVX2
  SIZE 0.9605 BY 3.33 ;
END INVX2
MACRO INVX3
  SIZE 0.9605 BY 3.33 ;
END INVX3
MACRO NANDX1
  RESIZE 9 BY 9 ;
  SIZE 1.92 BY 3.33 ;
END NANDX1
MACRO NANDX2
  SIZE 1.92 BY 3.33 ;
END NANDX2
MACRO DFFX1
  SIZE 6.24 BY 3.33 ;
END DFFX1
MACRO DFFX2
  SIZE 6.24 BY 3.33 ;
END DFFX2
MACRO TIEHI
  SIZE 0.96 BY 3.33 ;
END TIEHI
MACRO TIELO
  SIZE 0.96 BY 3.33 ;
END TIELO
MACRO ONLYTT1
  SIZE 0.48 BY 3.33 ;
END ONLYTT1
MACRO ONLYTT2
  SIZE 0.48 BY 3.33 ;
END ONLYTT2
MACRO NOSIZE
  CLASS CORE ;
END NOSIZE
MACRO FILL1
  CLASS CORE SPACER ;
  SIZE 0.48 BY 3.33 ;
  PIN VDD
    DIRECTION INOUT ;
    USE POWER ;
  END VDD
  PIN VSS
    USE GROUND ;
  END VSS
END FILL1
MACRO FILL2
  SIZE 0.96 BY 3.33 ;

  PIN VDD
    USE POWER ;
  END VDD

  PIN VSS
    USE  GROUND  ;
  END VSS
END FILL2
MACRO TAP
  SIZE 0.96 BY 3.33 ;
  PIN VDD
    USE POWER ;
  END VDD
  PIN SUB
    USE SIGNAL ;
  END SUB
END TAP
MACRO EMPTY
  SIZE 0.96 BY 3.33 ;
END EMPTY
END LIBRARY
